# Keil uVision project NT32_FreeRTOS.uvprojx, settings and files
target NT32_FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G032R8L7 Nationstech
  pack: Nationstech.N32G032_DFP.0.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NT32_FreeRTOS +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\Output\@L.bin !L
  AfterMake: Keil5_disp_size_bar_v0.3.exe
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G032,USE_STDPERIPH_DRIVER
  c include: .\App;.\firmware\CMSIS\core;.\firmware\CMSIS\device;.\firmware\n32g032_std_periph_driver\inc;.\User;.\FreeRTOS\include;.\FreeRTOS\port\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group App
    ./App/: systick.c usart.c key.c LED.c
    ./firmware/CMSIS/device/: system_n32g032.c
    ./firmware/CMSIS/device/startup/: startup_n32g032.s
  group FWLB
    ./firmware/n32g032_std_periph_driver/src/: misc.c n32g032_crc.c n32g032_flash.c n32g032_gpio.c n32g032_i2c.c n32g032_rcc.c n32g032_dma.c n32g032_usart.c
  group USER
    ./User/: main.c n32g032_it.c camera_data.h FreeRTOSConfig.h
  group FreeRTOS/port
    ./FreeRTOS/port/MemMang/: heap_4.c
    ./FreeRTOS/port/RVDS/ARM_CM0/: port.c
  group FreeRTOS/src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
